# Keil uVision project Konstrukcijsk.uvprojx, settings and files
target Konstrukcijsk (6070000::V6.7::.\ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M0")
  output: Konstrukcijsk
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_SPI_ASYNCH=1 DEVICE_I2CSLAVE=1 USE_HAL_DRIVER MBED_ROM_SIZE=0x20000 DEVICE_I2C=1 TARGET_STM MBED_BUILD_TIMESTAMP=1669933466.1721349 DEVICE_LPTICKER=1 TOOLCHAIN_ARMC6 TARGET_RELEASE DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGIN=1 DEVICE_SERIAL_ASYNCH=1 TARGET_NAME=NUCLEO_F072RB DEVICE_PWMOUT=1 MBED_RAM_START=0x20000000 DEVICE_USTICKER=1 DEVICE_CAN=1 DEVICE_SLEEP=1 TARGET_CORTEX_M TARGET_STM32F072RB TARGET_NUCLEO_F072RB DEVICE_RESET_REASON=1 MBED_ROM_START=0x8000000 __CMSIS_RTOS TARGET_FF_MORPHO __MBED__=1 __MICROLIB TARGET_LIKE_MBED DEVICE_PORTOUT=1 TARGET_LIKE_CORTEX_M0 TARGET_M0 DEVICE_WATCHDOG=1 DEVICE_INTERRUPTIN=1 MBED_TRAP_ERRORS_ENABLED=1 TRANSACTION_QUEUE_SIZE_SPI=2 TOOLCHAIN_ARM DEVICE_PORTIN=1 DEVICE_SPISLAVE=1 DEVICE_ANALOGOUT=1 MBED_MINIMAL_PRINTF DEVICE_PORTINOUT=1 __CORTEX_M0 TARGET_STM32F0 CMSIS_VECTAB_VIRTUAL MULADDC_CANNOT_USE_R7 DEVICE_CRC=1 DEVICE_RTC=1 TARGET_MCU_STM32 DEVICE_FLASH=1 DEVICE_SPI=1 MBED_RAM_SIZE=0x4000 TOOLCHAIN_ARM_STD MBED_RTOS_SINGLE_THREAD __MBED_CMSIS_RTOS_CM TARGET_CORTEX DEVICE_SERIAL=1 TARGET_MCU_STM32_BAREMETAL TARGET_FF_ARDUINO USE_FULL_LL_DRIVER CMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" ARM_MATH_CM0 DEVICE_SERIAL_FC=1 __ASSERT_MSG DEVICE_I2C_ASYNCH=1
  c misc: -mthumb -Wno-deprecated-register -Wno-armcc-pragma-push-pop -fdata-sections -mcpu=cortex-m0 -fshort-wchar -fno-exceptions -fshort-enums -c -fno-rtti -fno-c++-static-destructors --target=arm-arm-none-eabi -Wno-reserved-user-defined-literal -Wno-armcc-pragma-anon-unions -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;RegulatoNapona;mbed;mbed/TARGET_NUCLEO_F072RB/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DCMSIS_VECTAB_VIRTUAL,-D__CORTEX_M0,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DUSE_HAL_DRIVER,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DARM_MATH_CM0,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-DUSE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F072RB/TOOLCHAIN_ARM_STD/stm32f072rb.sct
  link misc: --library_type=microlib --legacyalign --inline --predefine="-DMBED_ROM_SIZE=0x20000" --any_contingency --show_full_path --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_SIZE=0x4000" --predefine="-DMBED_BOOT_STACK_SIZE=1024" --keep=os_cb_sections --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DXIP_ENABLE=0" --cpu=Cortex-M0
  group Konstrukcijsk
    ./: main.cpp mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F072RB/TOOLCHAIN_ARM_STD/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o arm_math.h can_api.o can_device.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_nvic.o cmsis_version.h common_objects.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h except.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.h gpio_irq_device.o gpio_object.h hal_tick_overrides.o i2c_api.o i2c_device.h lp_ticker.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_crc_api.o mbed_fault_handler.h mbed_fault_handler.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o mpu_armv7.h mpu_armv8.h nvic_addr.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pin_device.h pinmap.o PinNames.h PinNamesTypes.h port_api.o PortNames.h pwmout_api.o pwmout_device.h pwmout_device.o qspi_api.o rtc_api.o rtc_api_hal.h RTE_Components.h serial_api.o serial_api_hal.h serial_device.o sleep.o spi_api.o spi_device.h startup_stm32f072xb.o stm32_assert.h stm32_hal_legacy.h stm32f072xb.h stm32f0xx.h stm32f0xx_hal.h stm32f0xx_hal.o stm32f0xx_hal_adc.h stm32f0xx_hal_adc.o stm32f0xx_hal_adc_ex.h stm32f0xx_hal_adc_ex.o stm32f0xx_hal_can.h stm32f0xx_hal_can.o stm32f0xx_hal_cec.h stm32f0xx_hal_cec.o stm32f0xx_hal_comp.h stm32f0xx_hal_comp.o stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.h stm32f0xx_hal_cortex.o stm32f0xx_hal_crc.h stm32f0xx_hal_crc.o stm32f0xx_hal_crc_ex.h stm32f0xx_hal_crc_ex.o stm32f0xx_hal_dac.h stm32f0xx_hal_dac.o stm32f0xx_hal_dac_ex.h stm32f0xx_hal_dac_ex.o stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma.o stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash.o stm32f0xx_hal_flash_ex.h stm32f0xx_hal_flash_ex.o stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio.o stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c.o stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2c_ex.o stm32f0xx_hal_i2s.h stm32f0xx_hal_i2s.o stm32f0xx_hal_irda.h stm32f0xx_hal_irda.o stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.h stm32f0xx_hal_iwdg.o stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd.o stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pcd_ex.o stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr.o stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_pwr_ex.o stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc.o stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rcc_ex.o stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc.o stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_rtc_ex.o stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard.o stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smartcard_ex.o stm32f0xx_hal_smbus.h stm32f0xx_hal_smbus.o stm32f0xx_hal_spi.h stm32f0xx_hal_spi.o stm32f0xx_hal_spi_ex.h stm32f0xx_hal_spi_ex.o stm32f0xx_hal_tim.h stm32f0xx_hal_tim.o stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tim_ex.o stm32f0xx_hal_tsc.h stm32f0xx_hal_tsc.o stm32f0xx_hal_uart.h stm32f0xx_hal_uart.o stm32f0xx_hal_uart_ex.h stm32f0xx_hal_uart_ex.o stm32f0xx_hal_usart.h stm32f0xx_hal_usart.o stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.h stm32f0xx_hal_wwdg.o stm32f0xx_ll_adc.h stm32f0xx_ll_adc.o stm32f0xx_ll_bus.h stm32f0xx_ll_comp.h stm32f0xx_ll_comp.o stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.h stm32f0xx_ll_crc.o stm32f0xx_ll_crs.h stm32f0xx_ll_crs.o stm32f0xx_ll_dac.h stm32f0xx_ll_dac.o stm32f0xx_ll_dma.h stm32f0xx_ll_dma.o stm32f0xx_ll_exti.h stm32f0xx_ll_exti.o stm32f0xx_ll_gpio.h stm32f0xx_ll_gpio.o stm32f0xx_ll_i2c.h stm32f0xx_ll_i2c.o stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.h stm32f0xx_ll_pwr.o stm32f0xx_ll_rcc.h stm32f0xx_ll_rcc.o stm32f0xx_ll_rtc.h stm32f0xx_ll_rtc.o stm32f0xx_ll_spi.h stm32f0xx_ll_spi.o stm32f0xx_ll_system.h stm32f0xx_ll_tim.h stm32f0xx_ll_tim.o stm32f0xx_ll_usart.h stm32f0xx_ll_usart.o stm32f0xx_ll_utils.h stm32f0xx_ll_utils.o stm32f0xx_ll_wwdg.h stm_spi_api.o system_clock.o system_stm32f0xx.h system_stm32f0xx.o trng_api.o tz_context.h us_ticker.o us_ticker_data.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
  group RegulatoNapona
    RegulatoNapona/: RegulatorNapona.cpp RegulatorNapona.h
